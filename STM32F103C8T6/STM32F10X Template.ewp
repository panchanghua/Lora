# IAR project STM32F10X Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; CMSIS\; FWLIB\inc\; USER\; DRIVER\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F10X Template.hex
  ILINK.IlinkOutputFile: STM32F10X Template.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZC ST STM32F103ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: CMSIS\; DRIVER\inc\; FWLIB\inc\; USER\
  ICCARM.CCOptLevel: 3
  group CMSIS/startup
    CMSIS/STARTUP/: startup_stm32f10x_md.s
  group CMSIS/system
    CMSIS/: system_stm32f10x.c
  group DRIVER
    DRIVER/src/: adc.c dht11.c DS18B20.c key.c lcd.c led.c lsens.c timer.c usart.c
    DRIVER/inc/: sys.h
  group FWLIB
    FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    USER/: main.c stm32f10x_it.c
