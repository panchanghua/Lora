# Keil uVision project KFB.uvprojx, settings and files
target KFB (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: KFB
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rtc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_uart.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Application/User
    ../Src/: usart.c stm32l0xx_hal_msp.c i2c.c rtc.c stm32l0xx_it.c dma.c gpio.c main.c App.c Key.c LowPower.c Production_Test.c Lcd_App.c spi.c
    ../Hardware/: hdc1000.c Lorawan.c max7q.c mma8451.c mpl3115.c opt3001.c ILI9341.c XPT2046.c
software components: CMSIS:CORE 4.1.0
